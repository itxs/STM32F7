# IAR project uvc_practice_f7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; Inc; Middlewares\ST\STM32_USB_Device_Library\Core\Inc; Middlewares\ST\STM32_USB_Device_Library\Class\UVC\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uvc_practice_f7.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    Src/: stm32f7xx_it.c
  group Init
    Src/: stm32f7xx_hal_msp.c usb_device.c
  group USB
    Src/: usbd_conf.c
  group USB/DeviceClass
    Middlewares/ST/STM32_USB_Device_Library/Class/UVC/Src/: usbd_uvc.c
  group USB/DeviceCore
    Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    Src/: usbd_desc.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Board Support Buttons
    ${CMSIS_PACK_PATH_Keil#STM32F7xx_DFP#2.9.0}$/MDK/Boards/ST/STM32F746G_Discovery/Common/: Buttons_746G_Discovery.c
  group CMSIS-Pack/Board Support LED
    ${CMSIS_PACK_PATH_Keil#STM32F7xx_DFP#2.9.0}$/MDK/Boards/ST/STM32F746G_Discovery/Common/: LED_746G_Discovery.c
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.0.1}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Startup
    RTE/STM32F7xx_DFP/Keil/: startup_stm32f746xx.s system_stm32f7xx.c
    ${CMSIS_PACK_PATH_Keil#STM32F7xx_DFP#2.9.0}$/Drivers/CMSIS/Device/ST/STM32F7xx/Include/: stm32f7xx.h
  group CMSIS-Pack/Device STM32Cube Framework
    ${CMSIS_PACK_PATH_Keil#STM32F7xx_DFP#2.9.0}$/MDK/CubeMX/Documentation/: classic.html index.html
    RTE/STM32F7xx_DFP/Keil/: RTE_Device.h stm32f7xx_hal_conf.h
  group CMSIS-Pack/Device STM32Cube HAL
    ${CMSIS_PACK_PATH_Keil#STM32F7xx_DFP#2.9.0}$/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_usb.c
    ${CMSIS_PACK_PATH_Keil#STM32F7xx_DFP#2.9.0}$/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h
