<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uvc_practice_f7.ewp</path>
    </project>
    <batchBuild />
</workspace>
