# IAR project Backup of f7_usb_hs_uvc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USB_OTG_HS_CORE; HSE_VALUE=25000000
  ICCARM.CCIncludePath2: Library\STM32_USB_Device_Library\Class\CustomHID\Inc; Library\STM32_USB_Device_Library\Core\Inc; Library\STM32F7xx; Library\STM32F7xx_HAL_Driver\Inc; $PROJ_DIR$; Library\STM32_USB_Device_Library; Init; Library\STM32_USB_Device_Library\Class\UVC\inc; ..\Libraries\stuff
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: f7_usb_hs.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: color_models.c main.c stm32f7xx_it.c
  group Device
    Library/STM32F7xx/: startup_stm32f746xx.s system_stm32f7xx.c
  group HAL
    Library/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_usb.c
  group Init
    Init/: gpio.c rcc.c
  group USB Device library
    Library/STM32_USB_Device_Library/: usb_device.c usbd_conf.c usbd_desc.c
    Library/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./: usbd_usr.c
  group USB Device library/UVC
    Library/STM32_USB_Device_Library/Class/UVC/src/: usbd_video_core.c
