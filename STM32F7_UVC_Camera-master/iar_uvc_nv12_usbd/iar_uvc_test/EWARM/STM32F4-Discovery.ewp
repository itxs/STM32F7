# IAR project STM32F4-Discovery.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_USB_OTG_FS; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32_USB_Device_Library\Class\video\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32F4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4-Discovery.hex
  ILINK.IlinkOutputFile: STM32F4-Discovery_Demo.out
  ILINK.IlinkIcfFile: STM32F4-Discovery2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group HAL
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_msp.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group STM32_USB_Device_Library/Class/video
    ../../Libraries/STM32_USB_Device_Library/Class/video/src/: usbd_video_core.c
  group STM32_USB_Device_Library/Core
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../: main.c stm32f4xx_it.c usb_bsp.c usb_conf.h usbd_conf.h usbd_desc.c usbd_usr.c
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
